# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=111
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\FWLIB\inc;..\HARDWARE\TOUCH;..\HARDWARE\SPI;..\HARDWARE\DMA;..\SYSTEM\usart;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\UCOS_BSP;..\UCOSIII\UCOS_CONFIG;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\UCOSIII\uCOS-III;..\UCOSIII\uCOS-III\Source;..\HARDWARE\TIMER;..\GUI;..\GUI\lvgl;..\GUI\lv_examples;..\GUI\lv_driver;..\GUI_APP;..\GUI_APP\APP_START;..\GUI_APP\APP_anim;..\HARDWARE\RTC;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\IIC2;..\HARDWARE\DMP;..\HARDWARE\BMP180;..\HARDWARE\menu;..\GUI_APP\APP_meun;..\GUI_APP\APP_image;..\GUI_APP\APP_about;..\GUI_APP\APP_clock;..\GUI_APP\APP_game;..\GUI_APP\APP_lighting;..\HARDWARE\PWM;..\HARDWARE\ADC;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c GUI.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: SPI.c
    ../HARDWARE/DMA/: dma.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/IIC2/: IOI2C.c
    ../HARDWARE/BMP180/: BMP180.c
    ../HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/menu/: menu.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_pwr.c stm32f4xx_sdio.c stm32f4xx_exti.c stm32f4xx_rtc.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ../UCOSIII/UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group GUI
    ../GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../GUI/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../GUI/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../GUI/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../GUI/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
    ../GUI/lv_driver/: lv_port_disp.c
  group GUI_APP
    ../GUI_APP/APP_START/: app_start.c
    ../GUI_APP/APP_anim/: app_anim.c
    ../GUI_APP/APP_meun/: app_meun.c
    ../GUI_APP/APP_about/: app_about.c
    ../GUI_APP/APP_clock/: app_clock.c
    ../GUI_APP/APP_game/: app_game.c
    ../GUI_APP/APP_lighting/: app_lighting.c
  group APP_image
    ../GUI_APP/APP_image/: start.c people1.c people2.c people3.c people4.c people5.c people6.c people7.c people8.c people9.c people10.c people11.c people12.c people13.c people14.c people15.c people16.c people17.c people18.c people19.c people20.c people21.c people22.c people23.c people24.c people25.c people26.c people27.c people28.c people29.c people30.c main_back.c about.c clock.c game.c lighting.c
  group APP_frot
    ../GUI_APP/APP_font/: my_font_icon_num60.c my_font_icon_num20.c my_font_icon_30.c my_font_icon_31.c
